# Repository iotlibre/modbus

## KiCad design ecomodbus-hardware/ecoBeat_3.kicad_pcb

Parts:
C1: 10nF; C_1206_HandSoldering
C2: 10uF; C_1206_HandSoldering
D1, D3: LED; LED-3MM
F1: Fuse; Fuse_Horizontal_RM10mm
J1: AC_input; bornier2
J2: Conn_MODBUS; bornier3
J3: Test_5V; SolderWirePad_single_0-8mmDrill
P1: CONN_VCC; Pin_Header_Straight_1x08
P2: CONN_DATOS; Pin_Header_Straight_1x08
R1, R2, R3, R4: 10K; R_1206
R5, R9: 20K; R_1206
R6, R8: 220; R_1206
R10: 120; R_1206
U1: WeMos_mini; D1_mini_board
U2: ACDC-5V; vigortronix
U3: MAX_485; SOIC-8-N

Connections:
/5.0V: C1.1, C2.1, J3.1, P1.8, R1.2, R2.2, R3.2, R4.2, R5.2, R8.2, U2.4 (5V+), U3.8 (VCC)
/L1: P1.5, R6.2
/driver: P2.5, R3.1, U3.3 (DE)
/receiver: P2.4, R2.1, U3.2 (~RE~)
/rx_wemos: P1.2, R1.1, U3.1 (RO)
/tx_wemos: P1.1, R4.1, U3.4 (DI)
GND: C1.2, C2.2, D1.1 (K), D3.1 (K), J2.3, P1.7, R9.1, U2.3 (5v-), U3.5 (GND)
unnamed: D1.2 (A), R6.1
unnamed: D3.2 (A), R8.1
unnamed: F1.1, J1.2
unnamed: F1.2, U2.1 (AC)
unnamed: J1.1, U2.2 (AC)
unnamed: J2.1, R5.1, R10.1, U3.6 (A)
unnamed: J2.2, R9.2, R10.2, U3.7 (B)

Board: 2 copper layers, 30.9 x 86.0 mm, 21 parts (0 on the bottom side), 14 nets.

## Commit log

2018-08-28 first version hw + sw
2018-08-29 menor changes
2018-09-03 version for supercal 531
2018-09-03 led gehaviour
2018-10-10 Alpedrete version
2018-10-10 intensity transformer 1000A
